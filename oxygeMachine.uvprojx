# Keil uVision project oxygeMachine.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC506u7)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: oxygeMachine_24_4_16 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APP;.\CMSIS;.\CMSIS\include;.\StdPeriphLib\Include;.\Core\lnc;.\key_board;.\SEGGER\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ./APP/: gd32f10x_it.c gd32f10x_it.h gd32f10x_libopt.h main.c systick.c systick.h board_gpio1.c board_gpio1.h board_usart.c board_usart.h
    ./Core/src/: bsp.c bsp_timer.c bsp_uart.c bsp_key.c bsp_led.c key_board.c key_board_sample.c
  group CMSIS
    ./CMSIS/: system_gd32f10x.c
  group StdPeriphLib
    ./StdPeriphLib/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ./Startup/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group SEGGER
    ./SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
